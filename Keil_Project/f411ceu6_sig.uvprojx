# Keil uVision project f411ceu6_sig.uvprojx, settings and files
target f411ceu6_sig (6190000::V6.19::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f411ceu6_sig +hex
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=6 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F411xE,ARM_MATH_CM4
  c include: .;..\sAPP;..\sBSP;..\sDRV;..\sHMI;..\sMID;..\sUSER;..\HAL\STM32F4xx_HAL_Driver\Inc;..\HAL\CMSIS\Device\ST\STM32F4xx\Include;..\HAL\STM32F4xx_HAL_Driver\Inc\Legacy;..\HAL\CMSIS\DSP\Include;..\HAL\CMSIS\Include;..\sMID\FreeRTOS\include;..\sMID\FreeRTOS\portable\MemMang;..\sMID\FreeRTOS;..\sMID\FreeRTOS\portable\GCC;..\sMID\FreeRTOS-Plus-CLI;..\sMID\cot_menu;..\sMID\sGenBtnDrv2;..\sMID\sGraphic2D;.cmsis\include;RTE\_Target 1;..\sMID\sLib;..\sMID\lvgl;..\sMID\lvgl\src
  asm define: USE_HAL_DRIVER,STM32F411xE,ARM_MATH_CM4
  asm include: ..\sUSER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group ../SMID/LVGL/TESTS/UNITY
    ../sMID/lvgl/tests/unity/: unity.c unity_support.c
  group ../SMID/LVGL/TESTS/TEST_IMAGES/STRIDE_ALIGN64/UNCOMPRESSED
    ../sMID/lvgl/tests/test_images/stride_align64/UNCOMPRESSED/: test_A1_NONE_align64.c test_A2_NONE_align64.c test_A4_NONE_align64.c test_A8_NONE_align64.c test_ARGB8888_NONE_align64.c test_I1_NONE_align64.c test_I2_NONE_align64.c test_I4_NONE_align64.c test_I8_NONE_align64.c test_L8_NONE_align64.c test_RGB565A8_NONE_align64.c test_RGB565_NONE_align64.c test_RGB888_NONE_align64.c test_XRGB8888_NONE_align64.c
  group ../SMID/LVGL/TESTS/TEST_IMAGES/STRIDE_ALIGN64/RLE
    ../sMID/lvgl/tests/test_images/stride_align64/RLE/: test_A1_RLE_align64.c test_A2_RLE_align64.c test_A4_RLE_align64.c test_A8_RLE_align64.c test_ARGB8888_RLE_align64.c test_I1_RLE_align64.c test_I2_RLE_align64.c test_I4_RLE_align64.c test_I8_RLE_align64.c test_L8_RLE_align64.c test_RGB565A8_RLE_align64.c test_RGB565_RLE_align64.c test_RGB888_RLE_align64.c test_XRGB8888_RLE_align64.c
  group ../SMID/LVGL/TESTS/TEST_IMAGES/STRIDE_ALIGN64/LZ4
    ../sMID/lvgl/tests/test_images/stride_align64/LZ4/: test_A1_LZ4_align64.c test_A2_LZ4_align64.c test_A4_LZ4_align64.c test_A8_LZ4_align64.c test_ARGB8888_LZ4_align64.c test_I1_LZ4_align64.c test_I2_LZ4_align64.c test_I4_LZ4_align64.c test_I8_LZ4_align64.c test_L8_LZ4_align64.c test_RGB565A8_LZ4_align64.c test_RGB565_LZ4_align64.c test_RGB888_LZ4_align64.c test_XRGB8888_LZ4_align64.c
  group ../SMID/LVGL/TESTS/TEST_IMAGES/STRIDE_ALIGN1/UNCOMPRESSED
    ../sMID/lvgl/tests/test_images/stride_align1/UNCOMPRESSED/: test_A1_NONE_align1.c test_A2_NONE_align1.c test_A4_NONE_align1.c test_A8_NONE_align1.c test_ARGB8888_NONE_align1.c test_I1_NONE_align1.c test_I2_NONE_align1.c test_I4_NONE_align1.c test_I8_NONE_align1.c test_L8_NONE_align1.c test_RGB565A8_NONE_align1.c test_RGB565_NONE_align1.c test_RGB888_NONE_align1.c test_XRGB8888_NONE_align1.c
  group ../SMID/LVGL/TESTS/TEST_IMAGES/STRIDE_ALIGN1/RLE
    ../sMID/lvgl/tests/test_images/stride_align1/RLE/: test_A1_RLE_align1.c test_A2_RLE_align1.c test_A4_RLE_align1.c test_A8_RLE_align1.c test_ARGB8888_RLE_align1.c test_I1_RLE_align1.c test_I2_RLE_align1.c test_I4_RLE_align1.c test_I8_RLE_align1.c test_L8_RLE_align1.c test_RGB565A8_RLE_align1.c test_RGB565_RLE_align1.c test_RGB888_RLE_align1.c test_XRGB8888_RLE_align1.c
  group ../SMID/LVGL/TESTS/TEST_IMAGES/STRIDE_ALIGN1/LZ4
    ../sMID/lvgl/tests/test_images/stride_align1/LZ4/: test_A1_LZ4_align1.c test_A2_LZ4_align1.c test_A4_LZ4_align1.c test_A8_LZ4_align1.c test_ARGB8888_LZ4_align1.c test_I1_LZ4_align1.c test_I2_LZ4_align1.c test_I4_LZ4_align1.c test_I8_LZ4_align1.c test_L8_LZ4_align1.c test_RGB565A8_LZ4_align1.c test_RGB565_LZ4_align1.c test_RGB888_LZ4_align1.c test_XRGB8888_LZ4_align1.c
  group ../SMID/LVGL/TESTS/SRC
    ../sMID/lvgl/tests/src/: lv_test_helpers.c lv_test_indev.c lv_test_init.c
  group ../SMID/LVGL/TESTS/SRC/TEST_LIBS/RND_UNICODES
    ../sMID/lvgl/tests/src/test_libs/rnd_unicodes/: lv_rnd_unicodes.c
  group ../SMID/LVGL/TESTS/SRC/TEST_LIBS/RND_UNICODES/RND_UNICODES/SRC
    ../sMID/lvgl/tests/src/test_libs/rnd_unicodes/rnd_unicodes/src/: library.c
  group ../SMID/LVGL/TESTS/SRC/TEST_CASES
    ../sMID/lvgl/tests/src/test_cases/: test_anim.c test_anim_timeline.c test_array.c test_bindings.c test_config.c test_demo_stress.c test_demo_widgets.c test_draw_buf_stride.c test_event.c test_font_loader.c test_fs.c test_grid.c test_group.c test_margin_align.c test_margin_flex.c test_margin_grid.c test_math.c test_mem.c test_observer.c test_profiler.c test_screen_load.c test_snapshot.c test_style.c test_txt.c _test_template.c
  group ../SMID/LVGL/TESTS/SRC/TEST_CASES/WIDGETS
    ../sMID/lvgl/tests/src/test_cases/widgets/: test_animimg.c test_arc.c test_bar.c test_btn.c test_btnmatrix.c test_calendar.c test_chart.c test_checkbox.c test_dropdown.c test_image.c test_image_property.c test_imgfont.c test_keyboard.c test_label.c test_led.c test_line.c test_list.c test_msgbox.c test_objid.c test_obj_flags.c test_obj_property.c test_obj_tree.c test_roller.c test_scale.c test_slider.c test_span.c test_spinbox.c test_spinner.c test_switch.c test_table.c test_tabview.c test_textarea.c test_win.c
  group ../SMID/LVGL/TESTS/SRC/TEST_CASES/LIBS
    ../sMID/lvgl/tests/src/test_cases/libs/: test_barcode.c test_font_stress.c test_freetype.c test_libjpeg_turbo.c test_libpng.c test_lodepng.c test_memmove.c test_qrcode.c test_tiny_ttf.c test_tjpgd.c
  group ../SMID/LVGL/TESTS/SRC/TEST_CASES/DRAW
    ../sMID/lvgl/tests/src/test_cases/draw/: test_clip_corner.c test_draw_blend.c test_draw_label.c test_draw_layer.c test_draw_sw_rotate.c test_draw_vector.c test_image_formats.c test_layer_transform.c test_render_to_argb8888.c test_render_to_rgb565.c test_render_to_rgb888.c test_render_to_xrgb8888.c
  group ../SMID/LVGL/TESTS/SRC/TEST_CASES/CACHE
    ../sMID/lvgl/tests/src/test_cases/cache/: test_cache.c
  group ../SMID/LVGL/TESTS/SRC/TEST_ASSETS
    ../sMID/lvgl/tests/src/test_assets/: test_animimg001.c test_animimg002.c test_animimg003.c test_arc_bg.c test_font_1.c test_font_1_bin.c test_font_2.c test_font_2_bin.c test_font_3.c test_font_3_bin.c test_font_montserrat_ascii_1bpp.c test_font_montserrat_ascii_2bpp.c test_font_montserrat_ascii_4bpp.c test_font_montserrat_ascii_4bpp_compressed.c test_img_caret_down.c test_img_cogwheel_a8.c test_img_cogwheel_argb8888.c test_img_cogwheel_i4.c test_img_cogwheel_rgb565.c test_img_cogwheel_rgb565a8.c test_img_cogwheel_xrgb8888.c test_img_emoji_F617.c test_img_lvgl_logo_jpg.c test_img_lvgl_logo_png.c test_kern_one_otf.c test_ubuntu_font.c
  group ../SMID/LVGL/TESTS/MAKEFILE
    ../sMID/lvgl/tests/makefile/: test.c
  group ../SMID/LVGL/SRC
    ../sMID/lvgl/src/: lv_init.c
  group ../SMID/LVGL/SRC/WIDGETS/WIN
    ../sMID/lvgl/src/widgets/win/: lv_win.c
  group ../SMID/LVGL/SRC/WIDGETS/TILEVIEW
    ../sMID/lvgl/src/widgets/tileview/: lv_tileview.c
  group ../SMID/LVGL/SRC/WIDGETS/TEXTAREA
    ../sMID/lvgl/src/widgets/textarea/: lv_textarea.c
  group ../SMID/LVGL/SRC/WIDGETS/TABVIEW
    ../sMID/lvgl/src/widgets/tabview/: lv_tabview.c
  group ../SMID/LVGL/SRC/WIDGETS/TABLE
    ../sMID/lvgl/src/widgets/table/: lv_table.c
  group ../SMID/LVGL/SRC/WIDGETS/SWITCH
    ../sMID/lvgl/src/widgets/switch/: lv_switch.c
  group ../SMID/LVGL/SRC/WIDGETS/SPINNER
    ../sMID/lvgl/src/widgets/spinner/: lv_spinner.c
  group ../SMID/LVGL/SRC/WIDGETS/SPINBOX
    ../sMID/lvgl/src/widgets/spinbox/: lv_spinbox.c
  group ../SMID/LVGL/SRC/WIDGETS/SPAN
    ../sMID/lvgl/src/widgets/span/: lv_span.c
  group ../SMID/LVGL/SRC/WIDGETS/SLIDER
    ../sMID/lvgl/src/widgets/slider/: lv_slider.c
  group ../SMID/LVGL/SRC/WIDGETS/SCALE
    ../sMID/lvgl/src/widgets/scale/: lv_scale.c
  group ../SMID/LVGL/SRC/WIDGETS/ROLLER
    ../sMID/lvgl/src/widgets/roller/: lv_roller.c
  group ../SMID/LVGL/SRC/WIDGETS/OBJX_TEMPL
    ../sMID/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
  group ../SMID/LVGL/SRC/WIDGETS/MSGBOX
    ../sMID/lvgl/src/widgets/msgbox/: lv_msgbox.c
  group ../SMID/LVGL/SRC/WIDGETS/MENU
    ../sMID/lvgl/src/widgets/menu/: lv_menu.c
  group ../SMID/LVGL/SRC/WIDGETS/LIST
    ../sMID/lvgl/src/widgets/list/: lv_list.c
  group ../SMID/LVGL/SRC/WIDGETS/LINE
    ../sMID/lvgl/src/widgets/line/: lv_line.c
  group ../SMID/LVGL/SRC/WIDGETS/LED
    ../sMID/lvgl/src/widgets/led/: lv_led.c
  group ../SMID/LVGL/SRC/WIDGETS/LABEL
    ../sMID/lvgl/src/widgets/label/: lv_label.c
  group ../SMID/LVGL/SRC/WIDGETS/KEYBOARD
    ../sMID/lvgl/src/widgets/keyboard/: lv_keyboard.c
  group ../SMID/LVGL/SRC/WIDGETS/IMAGEBUTTON
    ../sMID/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
  group ../SMID/LVGL/SRC/WIDGETS/IMAGE
    ../sMID/lvgl/src/widgets/image/: lv_image.c
  group ../SMID/LVGL/SRC/WIDGETS/DROPDOWN
    ../sMID/lvgl/src/widgets/dropdown/: lv_dropdown.c
  group ../SMID/LVGL/SRC/WIDGETS/CHECKBOX
    ../sMID/lvgl/src/widgets/checkbox/: lv_checkbox.c
  group ../SMID/LVGL/SRC/WIDGETS/CHART
    ../sMID/lvgl/src/widgets/chart/: lv_chart.c
  group ../SMID/LVGL/SRC/WIDGETS/CANVAS
    ../sMID/lvgl/src/widgets/canvas/: lv_canvas.c
  group ../SMID/LVGL/SRC/WIDGETS/CALENDAR
    ../sMID/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
  group ../SMID/LVGL/SRC/WIDGETS/BUTTONMATRIX
    ../sMID/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
  group ../SMID/LVGL/SRC/WIDGETS/BUTTON
    ../sMID/lvgl/src/widgets/button/: lv_button.c
  group ../SMID/LVGL/SRC/WIDGETS/BAR
    ../sMID/lvgl/src/widgets/bar/: lv_bar.c
  group ../SMID/LVGL/SRC/WIDGETS/ARC
    ../sMID/lvgl/src/widgets/arc/: lv_arc.c
  group ../SMID/LVGL/SRC/WIDGETS/ANIMIMAGE
    ../sMID/lvgl/src/widgets/animimage/: lv_animimage.c
  group ../SMID/LVGL/SRC/TICK
    ../sMID/lvgl/src/tick/: lv_tick.c
  group ../SMID/LVGL/SRC/THEMES
    ../sMID/lvgl/src/themes/: lv_theme.c
  group ../SMID/LVGL/SRC/THEMES/SIMPLE
    ../sMID/lvgl/src/themes/simple/: lv_theme_simple.c
  group ../SMID/LVGL/SRC/THEMES/MONO
    ../sMID/lvgl/src/themes/mono/: lv_theme_mono.c
  group ../SMID/LVGL/SRC/THEMES/DEFAULT
    ../sMID/lvgl/src/themes/default/: lv_theme_default.c
  group ../SMID/LVGL/SRC/STDLIB
    ../sMID/lvgl/src/stdlib/: lv_mem.c
  group ../SMID/LVGL/SRC/STDLIB/RTTHREAD
    ../sMID/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
  group ../SMID/LVGL/SRC/STDLIB/MICROPYTHON
    ../sMID/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
  group ../SMID/LVGL/SRC/STDLIB/CLIB
    ../sMID/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
  group ../SMID/LVGL/SRC/STDLIB/BUILTIN
    ../sMID/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
  group ../SMID/LVGL/SRC/OTHERS/VG_LITE_TVG
    ../sMID/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c vg_lite_tvg.cpp
  group ../SMID/LVGL/SRC/OTHERS/SYSMON
    ../sMID/lvgl/src/others/sysmon/: lv_sysmon.c
  group ../SMID/LVGL/SRC/OTHERS/SNAPSHOT
    ../sMID/lvgl/src/others/snapshot/: lv_snapshot.c
  group ../SMID/LVGL/SRC/OTHERS/OBSERVER
    ../sMID/lvgl/src/others/observer/: lv_observer.c
  group ../SMID/LVGL/SRC/OTHERS/MONKEY
    ../sMID/lvgl/src/others/monkey/: lv_monkey.c
  group ../SMID/LVGL/SRC/OTHERS/IMGFONT
    ../sMID/lvgl/src/others/imgfont/: lv_imgfont.c
  group ../SMID/LVGL/SRC/OTHERS/IME
    ../sMID/lvgl/src/others/ime/: lv_ime_pinyin.c
  group ../SMID/LVGL/SRC/OTHERS/GRIDNAV
    ../sMID/lvgl/src/others/gridnav/: lv_gridnav.c
  group ../SMID/LVGL/SRC/OTHERS/FRAGMENT
    ../sMID/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
  group ../SMID/LVGL/SRC/OTHERS/FILE_EXPLORER
    ../sMID/lvgl/src/others/file_explorer/: lv_file_explorer.c
  group ../SMID/LVGL/SRC/OSAL
    ../sMID/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_windows.c
  group ../SMID/LVGL/SRC/MISC
    ../sMID/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_utils.c
  group ../SMID/LVGL/SRC/MISC/CACHE
    ../sMID/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_image_cache.c _lv_cache_lru_rb.c
  group ../SMID/LVGL/SRC/LIBS/TJPGD
    ../sMID/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
  group ../SMID/LVGL/SRC/LIBS/TINY_TTF
    ../sMID/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
  group ../SMID/LVGL/SRC/LIBS/THORVG
    ../sMID/lvgl/src/libs/thorvg/: tvgAnimation.cpp tvgBezier.cpp tvgCanvas.cpp tvgCapi.cpp tvgCompressor.cpp tvgFill.cpp tvgInitializer.cpp tvgLoader.cpp tvgMath.cpp tvgPaint.cpp tvgPicture.cpp tvgRawLoader.cpp tvgRender.cpp tvgSaver.cpp tvgScene.cpp tvgShape.cpp tvgStr.cpp tvgSvgCssStyle.cpp tvgSvgLoader.cpp tvgSvgPath.cpp tvgSvgSceneBuilder.cpp tvgSvgUtil.cpp tvgSwCanvas.cpp tvgSwFill.cpp tvgSwImage.cpp tvgSwMath.cpp tvgSwMemPool.cpp tvgSwRaster.cpp tvgSwRenderer.cpp tvgSwRle.cpp tvgSwShape.cpp tvgSwStroke.cpp tvgTaskScheduler.cpp tvgXmlParser.cpp
  group ../SMID/LVGL/SRC/LIBS/RLOTTIE
    ../sMID/lvgl/src/libs/rlottie/: lv_rlottie.c
  group ../SMID/LVGL/SRC/LIBS/RLE
    ../sMID/lvgl/src/libs/rle/: lv_rle.c
  group ../SMID/LVGL/SRC/LIBS/QRCODE
    ../sMID/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
  group ../SMID/LVGL/SRC/LIBS/LZ4
    ../sMID/lvgl/src/libs/lz4/: lz4.c
  group ../SMID/LVGL/SRC/LIBS/LODEPNG
    ../sMID/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
  group ../SMID/LVGL/SRC/LIBS/LIBPNG
    ../sMID/lvgl/src/libs/libpng/: lv_libpng.c
  group ../SMID/LVGL/SRC/LIBS/LIBJPEG_TURBO
    ../sMID/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
  group ../SMID/LVGL/SRC/LIBS/GIF
    ../sMID/lvgl/src/libs/gif/: gifdec.c lv_gif.c
  group ../SMID/LVGL/SRC/LIBS/FSDRV
    ../sMID/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
  group ../SMID/LVGL/SRC/LIBS/FREETYPE
    ../sMID/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
  group ../SMID/LVGL/SRC/LIBS/FFMPEG
    ../sMID/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
  group ../SMID/LVGL/SRC/LIBS/BMP
    ../sMID/lvgl/src/libs/bmp/: lv_bmp.c
  group ../SMID/LVGL/SRC/LIBS/BIN_DECODER
    ../sMID/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
  group ../SMID/LVGL/SRC/LIBS/BARCODE
    ../sMID/lvgl/src/libs/barcode/: code128.c lv_barcode.c
  group ../SMID/LVGL/SRC/LAYOUTS
    ../sMID/lvgl/src/layouts/: lv_layout.c
  group ../SMID/LVGL/SRC/LAYOUTS/GRID
    ../sMID/lvgl/src/layouts/grid/: lv_grid.c
  group ../SMID/LVGL/SRC/LAYOUTS/FLEX
    ../sMID/lvgl/src/layouts/flex/: lv_flex.c
  group ../SMID/LVGL/SRC/INDEV
    ../sMID/lvgl/src/indev/: lv_indev.c lv_indev_scroll.c
  group ../SMID/LVGL/SRC/FONT
    ../sMID/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group ../SMID/LVGL/SRC/DRIVERS/X11
    ../sMID/lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
  group ../SMID/LVGL/SRC/DRIVERS/WINDOWS
    ../sMID/lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
  group ../SMID/LVGL/SRC/DRIVERS/SDL
    ../sMID/lvgl/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
  group ../SMID/LVGL/SRC/DRIVERS/NUTTX
    ../sMID/lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
  group ../SMID/LVGL/SRC/DRIVERS/LIBINPUT
    ../sMID/lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
  group ../SMID/LVGL/SRC/DRIVERS/EVDEV
    ../sMID/lvgl/src/drivers/evdev/: lv_evdev.c
  group ../SMID/LVGL/SRC/DRIVERS/DISPLAY/TFT_ESPI
    ../sMID/lvgl/src/drivers/display/tft_espi/: lv_tft_espi.cpp
  group ../SMID/LVGL/SRC/DRIVERS/DISPLAY/ST7796
    ../sMID/lvgl/src/drivers/display/st7796/: lv_st7796.c
  group ../SMID/LVGL/SRC/DRIVERS/DISPLAY/ST7789
    ../sMID/lvgl/src/drivers/display/st7789/: lv_st7789.c
  group ../SMID/LVGL/SRC/DRIVERS/DISPLAY/ST7735
    ../sMID/lvgl/src/drivers/display/st7735/: lv_st7735.c
  group ../SMID/LVGL/SRC/DRIVERS/DISPLAY/LCD
    ../sMID/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
  group ../SMID/LVGL/SRC/DRIVERS/DISPLAY/ILI9341
    ../sMID/lvgl/src/drivers/display/ili9341/: lv_ili9341.c
  group ../SMID/LVGL/SRC/DRIVERS/DISPLAY/FB
    ../sMID/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
  group ../SMID/LVGL/SRC/DRIVERS/DISPLAY/DRM
    ../sMID/lvgl/src/drivers/display/drm/: lv_linux_drm.c
  group ../SMID/LVGL/SRC/DRAW
    ../sMID/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
  group ../SMID/LVGL/SRC/DRAW/VG_LITE
    ../sMID/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_utils.c
  group ../SMID/LVGL/SRC/DRAW/SW
    ../sMID/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
  group ../SMID/LVGL/SRC/DRAW/SW/BLEND
    ../sMID/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
  group ../SMID/LVGL/SRC/DRAW/SW/BLEND/NEON
    ../sMID/lvgl/src/draw/sw/blend/neon/: lv_blend_neon.S
  group ../SMID/LVGL/SRC/DRAW/SW/BLEND/HELIUM
    ../sMID/lvgl/src/draw/sw/blend/helium/: lv_blend_helium.S
  group ../SMID/LVGL/SRC/DRAW/SDL
    ../sMID/lvgl/src/draw/sdl/: lv_draw_sdl.c
  group ../SMID/LVGL/SRC/DRAW/RENESAS/DAVE2D
    ../sMID/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
  group ../SMID/LVGL/SRC/DRAW/NXP/VGLITE
    ../sMID/lvgl/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_draw_vglite_triangle.c lv_vglite_buf.c lv_vglite_matrix.c lv_vglite_path.c lv_vglite_utils.c
  group ../SMID/LVGL/SRC/DRAW/NXP/PXP
    ../sMID/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
  group ../SMID/LVGL/SRC/DISPLAY
    ../sMID/lvgl/src/display/: lv_display.c
  group ../SMID/LVGL/SRC/CORE
    ../sMID/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/WIN
    ../sMID/lvgl/examples/widgets/win/: lv_example_win_1.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/TILEVIEW
    ../sMID/lvgl/examples/widgets/tileview/: lv_example_tileview_1.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/TEXTAREA
    ../sMID/lvgl/examples/widgets/textarea/: lv_example_textarea_1.c lv_example_textarea_2.c lv_example_textarea_3.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/TABVIEW
    ../sMID/lvgl/examples/widgets/tabview/: lv_example_tabview_1.c lv_example_tabview_2.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/TABLE
    ../sMID/lvgl/examples/widgets/table/: lv_example_table_1.c lv_example_table_2.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/SWITCH
    ../sMID/lvgl/examples/widgets/switch/: lv_example_switch_1.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/SPINNER
    ../sMID/lvgl/examples/widgets/spinner/: lv_example_spinner_1.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/SPINBOX
    ../sMID/lvgl/examples/widgets/spinbox/: lv_example_spinbox_1.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/SPAN
    ../sMID/lvgl/examples/widgets/span/: lv_example_span_1.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/SLIDER
    ../sMID/lvgl/examples/widgets/slider/: lv_example_slider_1.c lv_example_slider_2.c lv_example_slider_3.c lv_example_slider_4.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/SCALE
    ../sMID/lvgl/examples/widgets/scale/: lv_example_scale_1.c lv_example_scale_2.c lv_example_scale_3.c lv_example_scale_4.c lv_example_scale_5.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/ROLLER
    ../sMID/lvgl/examples/widgets/roller/: lv_example_roller_1.c lv_example_roller_2.c lv_example_roller_3.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/OBJ
    ../sMID/lvgl/examples/widgets/obj/: lv_example_obj_1.c lv_example_obj_2.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/MSGBOX
    ../sMID/lvgl/examples/widgets/msgbox/: lv_example_msgbox_1.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/MENU
    ../sMID/lvgl/examples/widgets/menu/: lv_example_menu_1.c lv_example_menu_2.c lv_example_menu_3.c lv_example_menu_4.c lv_example_menu_5.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/LIST
    ../sMID/lvgl/examples/widgets/list/: lv_example_list_1.c lv_example_list_2.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/LINE
    ../sMID/lvgl/examples/widgets/line/: lv_example_line_1.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/LED
    ../sMID/lvgl/examples/widgets/led/: lv_example_led_1.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/LABEL
    ../sMID/lvgl/examples/widgets/label/: lv_example_label_1.c lv_example_label_2.c lv_example_label_3.c lv_example_label_4.c lv_example_label_5.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/KEYBOARD
    ../sMID/lvgl/examples/widgets/keyboard/: lv_example_keyboard_1.c lv_example_keyboard_2.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/IMAGEBUTTON
    ../sMID/lvgl/examples/widgets/imagebutton/: lv_example_imagebutton_1.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/IMAGE
    ../sMID/lvgl/examples/widgets/image/: lv_example_image_1.c lv_example_image_2.c lv_example_image_3.c lv_example_image_4.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/DROPDOWN
    ../sMID/lvgl/examples/widgets/dropdown/: lv_example_dropdown_1.c lv_example_dropdown_2.c lv_example_dropdown_3.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/CHECKBOX
    ../sMID/lvgl/examples/widgets/checkbox/: lv_example_checkbox_1.c lv_example_checkbox_2.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/CHART
    ../sMID/lvgl/examples/widgets/chart/: lv_example_chart_1.c lv_example_chart_2.c lv_example_chart_3.c lv_example_chart_4.c lv_example_chart_5.c lv_example_chart_6.c lv_example_chart_7.c lv_example_chart_8.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/CANVAS
    ../sMID/lvgl/examples/widgets/canvas/: lv_example_canvas_1.c lv_example_canvas_2.c lv_example_canvas_3.c lv_example_canvas_4.c lv_example_canvas_5.c lv_example_canvas_6.c lv_example_canvas_7.c lv_example_canvas_8.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/CALENDAR
    ../sMID/lvgl/examples/widgets/calendar/: lv_example_calendar_1.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/BUTTONMATRIX
    ../sMID/lvgl/examples/widgets/buttonmatrix/: lv_example_buttonmatrix_1.c lv_example_buttonmatrix_2.c lv_example_buttonmatrix_3.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/BUTTON
    ../sMID/lvgl/examples/widgets/button/: lv_example_button_1.c lv_example_button_2.c lv_example_button_3.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/BAR
    ../sMID/lvgl/examples/widgets/bar/: lv_example_bar_1.c lv_example_bar_2.c lv_example_bar_3.c lv_example_bar_4.c lv_example_bar_5.c lv_example_bar_6.c lv_example_bar_7.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/ARC
    ../sMID/lvgl/examples/widgets/arc/: lv_example_arc_1.c lv_example_arc_2.c
  group ../SMID/LVGL/EXAMPLES/WIDGETS/ANIMIMG
    ../sMID/lvgl/examples/widgets/animimg/: lv_example_animimg_1.c
  group ../SMID/LVGL/EXAMPLES/STYLES
    ../sMID/lvgl/examples/styles/: lv_example_style_1.c lv_example_style_10.c lv_example_style_11.c lv_example_style_12.c lv_example_style_13.c lv_example_style_14.c lv_example_style_15.c lv_example_style_2.c lv_example_style_3.c lv_example_style_4.c lv_example_style_5.c lv_example_style_6.c lv_example_style_7.c lv_example_style_8.c lv_example_style_9.c
  group ../SMID/LVGL/EXAMPLES/SCROLL
    ../sMID/lvgl/examples/scroll/: lv_example_scroll_1.c lv_example_scroll_2.c lv_example_scroll_3.c lv_example_scroll_4.c lv_example_scroll_5.c lv_example_scroll_6.c
  group ../SMID/LVGL/EXAMPLES/PORTING
    ../sMID/lvgl/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c lv_port_lcd_stm32_template.c
  group ../SMID/LVGL/EXAMPLES/OTHERS/SNAPSHOT
    ../sMID/lvgl/examples/others/snapshot/: lv_example_snapshot_1.c
  group ../SMID/LVGL/EXAMPLES/OTHERS/OBSERVER
    ../sMID/lvgl/examples/others/observer/: lv_example_observer_1.c lv_example_observer_2.c lv_example_observer_3.c lv_example_observer_4.c lv_example_observer_5.c lv_example_observer_6.c lv_example_observer_7.c
  group ../SMID/LVGL/EXAMPLES/OTHERS/MONKEY
    ../sMID/lvgl/examples/others/monkey/: lv_example_monkey_1.c lv_example_monkey_2.c lv_example_monkey_3.c
  group ../SMID/LVGL/EXAMPLES/OTHERS/IMGFONT
    ../sMID/lvgl/examples/others/imgfont/: lv_example_imgfont_1.c
  group ../SMID/LVGL/EXAMPLES/OTHERS/IME
    ../sMID/lvgl/examples/others/ime/: lv_example_ime_pinyin_1.c lv_example_ime_pinyin_2.c
  group ../SMID/LVGL/EXAMPLES/OTHERS/GRIDNAV
    ../sMID/lvgl/examples/others/gridnav/: lv_example_gridnav_1.c lv_example_gridnav_2.c lv_example_gridnav_3.c lv_example_gridnav_4.c
  group ../SMID/LVGL/EXAMPLES/OTHERS/FRAGMENT
    ../sMID/lvgl/examples/others/fragment/: lv_example_fragment_1.c lv_example_fragment_2.c
  group ../SMID/LVGL/EXAMPLES/OTHERS/FILE_EXPLORER
    ../sMID/lvgl/examples/others/file_explorer/: lv_example_file_explorer_1.c lv_example_file_explorer_2.c lv_example_file_explorer_3.c
  group ../SMID/LVGL/EXAMPLES/LIBS/TJPGD
    ../sMID/lvgl/examples/libs/tjpgd/: lv_example_tjpgd_1.c
  group ../SMID/LVGL/EXAMPLES/LIBS/TINY_TTF
    ../sMID/lvgl/examples/libs/tiny_ttf/: lv_example_tiny_ttf_1.c lv_example_tiny_ttf_2.c lv_example_tiny_ttf_3.c ubuntu_font.c
  group ../SMID/LVGL/EXAMPLES/LIBS/RLOTTIE
    ../sMID/lvgl/examples/libs/rlottie/: lv_example_rlottie_1.c lv_example_rlottie_2.c lv_example_rlottie_approve.c
  group ../SMID/LVGL/EXAMPLES/LIBS/QRCODE
    ../sMID/lvgl/examples/libs/qrcode/: lv_example_qrcode_1.c
  group ../SMID/LVGL/EXAMPLES/LIBS/LODEPNG
    ../sMID/lvgl/examples/libs/lodepng/: img_wink_png.c lv_example_lodepng_1.c
  group ../SMID/LVGL/EXAMPLES/LIBS/LIBPNG
    ../sMID/lvgl/examples/libs/libpng/: lv_example_libpng_1.c
  group ../SMID/LVGL/EXAMPLES/LIBS/LIBJPEG_TURBO
    ../sMID/lvgl/examples/libs/libjpeg_turbo/: lv_example_libjpeg_turbo_1.c
  group ../SMID/LVGL/EXAMPLES/LIBS/GIF
    ../sMID/lvgl/examples/libs/gif/: img_bulb_gif.c lv_example_gif_1.c
  group ../SMID/LVGL/EXAMPLES/LIBS/FREETYPE
    ../sMID/lvgl/examples/libs/freetype/: lv_example_freetype_1.c
  group ../SMID/LVGL/EXAMPLES/LIBS/FFMPEG
    ../sMID/lvgl/examples/libs/ffmpeg/: lv_example_ffmpeg_1.c lv_example_ffmpeg_2.c
  group ../SMID/LVGL/EXAMPLES/LIBS/BMP
    ../sMID/lvgl/examples/libs/bmp/: lv_example_bmp_1.c
  group ../SMID/LVGL/EXAMPLES/LIBS/BARCODE
    ../sMID/lvgl/examples/libs/barcode/: lv_example_barcode_1.c
  group ../SMID/LVGL/EXAMPLES/LAYOUTS/GRID
    ../sMID/lvgl/examples/layouts/grid/: lv_example_grid_1.c lv_example_grid_2.c lv_example_grid_3.c lv_example_grid_4.c lv_example_grid_5.c lv_example_grid_6.c
  group ../SMID/LVGL/EXAMPLES/LAYOUTS/FLEX
    ../sMID/lvgl/examples/layouts/flex/: lv_example_flex_1.c lv_example_flex_2.c lv_example_flex_3.c lv_example_flex_4.c lv_example_flex_5.c lv_example_flex_6.c
  group ../SMID/LVGL/EXAMPLES/GET_STARTED
    ../sMID/lvgl/examples/get_started/: lv_example_get_started_1.c lv_example_get_started_2.c lv_example_get_started_3.c lv_example_get_started_4.c
  group ../SMID/LVGL/EXAMPLES/EVENT
    ../sMID/lvgl/examples/event/: lv_example_event_1.c lv_example_event_2.c lv_example_event_3.c lv_example_event_4.c
  group ../SMID/LVGL/EXAMPLES/ASSETS
    ../sMID/lvgl/examples/assets/: animimg001.c animimg002.c animimg003.c imgbtn_left.c imgbtn_mid.c imgbtn_right.c img_caret_down.c img_cogwheel_argb.c img_cogwheel_indexed16.c img_cogwheel_rgb.c img_hand.c img_skew_strip.c img_star.c
  group ../SMID/LVGL/EXAMPLES/ASSETS/EMOJI
    ../sMID/lvgl/examples/assets/emoji/: img_emoji_F617.c
  group ../SMID/LVGL/EXAMPLES/ANIM
    ../sMID/lvgl/examples/anim/: lv_example_anim_1.c lv_example_anim_2.c lv_example_anim_3.c lv_example_anim_timeline_1.c
  group ../SMID/LVGL/ENV_SUPPORT/RT-THREAD
    ../sMID/lvgl/env_support/rt-thread/: lv_rt_thread_port.c
  group ../SMID/LVGL/ENV_SUPPORT/RT-THREAD/SQUARELINE
    ../sMID/lvgl/env_support/rt-thread/squareline/: lv_ui_entry.c
  group ../SMID/LVGL/ENV_SUPPORT/PIKASCRIPT
    ../sMID/lvgl/env_support/pikascript/: pika_lvgl.c pika_lvgl_indev_t.c pika_lvgl_lv_event.c pika_lvgl_lv_obj.c pika_lvgl_lv_style_t.c pika_lv_point_t.c pika_lv_timer_t.c pika_lv_wegit.c
  group ../SMID/LVGL/DEMOS
    ../sMID/lvgl/demos/: lv_demos.c
  group ../SMID/LVGL/DEMOS/WIDGETS
    ../sMID/lvgl/demos/widgets/: lv_demo_widgets.c
  group ../SMID/LVGL/DEMOS/WIDGETS/ASSETS
    ../sMID/lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
  group ../SMID/LVGL/DEMOS/VECTOR_GRAPHIC
    ../sMID/lvgl/demos/vector_graphic/: lv_demo_vector_graphic.c
  group ../SMID/LVGL/DEMOS/VECTOR_GRAPHIC/ASSETS
    ../sMID/lvgl/demos/vector_graphic/assets/: img_demo_vector_avatar.c
  group ../SMID/LVGL/DEMOS/TRANSFORM
    ../sMID/lvgl/demos/transform/: lv_demo_transform.c
  group ../SMID/LVGL/DEMOS/TRANSFORM/ASSETS
    ../sMID/lvgl/demos/transform/assets/: img_transform_avatar_15.c
  group ../SMID/LVGL/DEMOS/STRESS
    ../sMID/lvgl/demos/stress/: lv_demo_stress.c
  group ../SMID/LVGL/DEMOS/SCROLL
    ../sMID/lvgl/demos/scroll/: lv_demo_scroll.c
  group ../SMID/LVGL/DEMOS/RENDER
    ../sMID/lvgl/demos/render/: lv_demo_render.c
  group ../SMID/LVGL/DEMOS/RENDER/ASSETS
    ../sMID/lvgl/demos/render/assets/: img_render_arc_bg.c img_render_lvgl_logo_argb8888.c img_render_lvgl_logo_rgb565.c img_render_lvgl_logo_rgb888.c img_render_lvgl_logo_xrgb8888.c
  group ../SMID/LVGL/DEMOS/MUSIC
    ../sMID/lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
  group ../SMID/LVGL/DEMOS/MUSIC/ASSETS
    ../sMID/lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
  group ../SMID/LVGL/DEMOS/MULTILANG
    ../sMID/lvgl/demos/multilang/: lv_demo_multilang.c
  group ../SMID/LVGL/DEMOS/MULTILANG/ASSETS
    ../sMID/lvgl/demos/multilang/assets/: img_multilang_like.c
  group ../SMID/LVGL/DEMOS/MULTILANG/ASSETS/FONTS
    ../sMID/lvgl/demos/multilang/assets/fonts/: font_multilang_large.c font_multilang_small.c
  group ../SMID/LVGL/DEMOS/MULTILANG/ASSETS/EMOJIS
    ../sMID/lvgl/demos/multilang/assets/emojis/: img_emoji_artist_palette.c img_emoji_books.c img_emoji_camera_with_flash.c img_emoji_cat_face.c img_emoji_deciduous_tree.c img_emoji_dog_face.c img_emoji_earth_globe_europe_africa.c img_emoji_flexed_biceps.c img_emoji_movie_camera.c img_emoji_red_heart.c img_emoji_rocket.c img_emoji_soccer_ball.c
  group ../SMID/LVGL/DEMOS/MULTILANG/ASSETS/AVATARS
    ../sMID/lvgl/demos/multilang/assets/avatars/: img_multilang_avatar_1.c img_multilang_avatar_10.c img_multilang_avatar_11.c img_multilang_avatar_12.c img_multilang_avatar_13.c img_multilang_avatar_14.c img_multilang_avatar_15.c img_multilang_avatar_16.c img_multilang_avatar_17.c img_multilang_avatar_18.c img_multilang_avatar_19.c img_multilang_avatar_2.c img_multilang_avatar_22.c img_multilang_avatar_25.c img_multilang_avatar_3.c img_multilang_avatar_4.c img_multilang_avatar_5.c img_multilang_avatar_6.c img_multilang_avatar_7.c img_multilang_avatar_8.c img_multilang_avatar_9.c
  group ../SMID/LVGL/DEMOS/KEYPAD_ENCODER
    ../sMID/lvgl/demos/keypad_encoder/: lv_demo_keypad_encoder.c
  group ../SMID/LVGL/DEMOS/FLEX_LAYOUT
    ../sMID/lvgl/demos/flex_layout/: lv_demo_flex_layout_ctrl_pad.c lv_demo_flex_layout_flex_loader.c lv_demo_flex_layout_main.c lv_demo_flex_layout_view.c lv_demo_flex_layout_view_child_node.c lv_demo_flex_layout_view_ctrl_pad.c
  group ../SMID/LVGL/DEMOS/BENCHMARK
    ../sMID/lvgl/demos/benchmark/: lv_demo_benchmark.c
  group ../SMID/LVGL/DEMOS/BENCHMARK/ASSETS
    ../sMID/lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha256.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c lv_font_benchmark_montserrat_12_compr_az.c.c lv_font_benchmark_montserrat_16_compr_az.c.c lv_font_benchmark_montserrat_28_compr_az.c.c
  group sMID/sLib
    ../sMID/sLib/: sLib.c sLib_Ctrler.c sLib_Filter.c sLib_Reg.c
  group sMID/FreeRTOS-Plus-CLI
    ../sMID/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
  group sMID/FreeRTOS/port
    ../sMID/FreeRTOS/: FreeRTOSConfig.h
    ../sMID/FreeRTOS/portable/GCC/: port.c
    ../sMID/FreeRTOS/portable/MemMang/: heap_4.c
  group sMID/FreeRTOS/inc
    ../sMID/FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group sMID/FreeRTOS/src
    ../sMID/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group HAL
    ../HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c
  group sBSP
    ../sBSP/: sBSP_GPIO.c sBSP_RCC .c sBSP_UART.c sBSP_softI2C.c sBSP_TIMEBASE.c sBSP_SYS.c sBSP_SPI.c sBSP_TIM.c sBSP_RTC.c sBSP_F4_I2C.c sBSP_DWT.c sBSP_DMA.c
  group sHMI
    ../sHMI/: sHMI_Debug.c sHMI_LED.c
  group sDRV
    ../sDRV/: sDRV_ICM42688.c sDRV_LIS3MDLTR.c sDRV_LPS22HBTR.c sDRV_ST7789V.c
  group sUSER
    ../sUSER/: stm32f4xx_it.c stm32f4xx_hal_msp.c system_stm32f4xx.c startup_stm32f411xe.s stm32f4xx_hal_conf.h stm32f4xx_it.h main.h main.c
    ../HAL/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
